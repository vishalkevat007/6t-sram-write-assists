<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Apr 12 14:52:40 2026</timestamp>
			<uuid>{892dd3c7-2d84-480e-bede-1e6004101563}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ecegridfs/a/695v16/AVD_Project/write_assist_tb/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ecegridfs/a/695v16/AVD_Project/write_assist_tb/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ecegridfs/a/695v16/simulation/AVD_Project/write_assist_tb/maestro/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/ecegridfs/a/695v16/simulation/AVD_Project/write_assist_tb/maestro/results/maestro/ExplorerRun.0</simdir>
		</historyentry>
	</history>
</setupdb>
